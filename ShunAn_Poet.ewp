# IAR project ShunAn_Poet.ewp, settings and files
configuration RAM_128KB (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60F120M
  ICCARM.CCIncludePath2: ; Library\; Library\BlessedAlien\; ShunAn_Panel\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ShunAn_Poet.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\创作室\飞思卡尔智能小车\调试板\遥控器\configfiles\512KB_Pflash_512KB_Dflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_1MB (ARM)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: D:\创作室\飞思卡尔智能小车\顺暗三号\代码\顺暗三号-华南赛最后七天-7.11\configfiles\512KB_Pflash_512KB_Dflash.icf
  group Adam
    ShunAn_Panel/: main.c Pendulum_EndlessFormsMostBeautiful.c Pendulum_EndlessFormsMostBeautiful.h ThePoet_ThePendulum.c ThePoet_ThePendulum.h
  group CapitaineNemo
    ShunAn_Panel/: Poet_Buzzer.c Poet_Buzzer.h Poet_ImageBeholder.c Poet_ImageBeholder.h Poet_Motor.c Poet_Motor.h Poet_Scourage.c Poet_Scourage.h Poet_Servo.c Poet_Servo.h
  group DisplayPanel
    ShunAn_Panel/: Poet_Bluetooth.c Poet_Bluetooth.h Poet_InputInterface.c Poet_InputInterface.h Poet_Revelation.c Poet_Revelation.h
  group InertialNavigation
    ShunAn_Panel/: Poet_Navigation.c Poet_Navigation.h
  group Lib/defined
    Library/: arm_cm4.c arm_cm4.h MK60F15.c MK60F15.h
  group Lib/ShuAn_Lib
    Library/BlessedAlien/: BlessedAlien.c BlessedAlien.h ShunAn_Lib.c ShunAn_Lib.h
    Library/: IIC.c IIC.h
  group System
    ShunAn_Panel/: start_ShunAn.c start_ShunAn.h startup_ShunAn_K60FX512VLQ15.s
